# IAR project fir_seq.ewp, settings and files
configuration fir_seq (ARM, debug)
  General.OGChipSelectEditMenu: STM32U3C5ZI ST STM32U3C5ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_HSP_CUBE1_LEGACY; USE_HAL_DRIVER; STM32U3C5xx; USE_HSP_ARM_MATH_TYPES
  ICCARM.CCIncludePath2: ../HSP_Engine/App; ../HSP_Engine/Target; ../Core/Inc; ../../../../../../Drivers/STM32U3xx_HAL_Driver/Inc; ../../../../../../Drivers/STM32U3xx_HAL_Driver/Inc/Legacy; ../../../../../../Drivers/CMSIS/Device/ST/STM32U3xx/Include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/CMSIS/DSP/Include; ../../../../../../Drivers/CMSIS/DSP/Include/dsp; ../../../../../../Drivers/BSP/STM32U3xx_Nucleo; ../../../../../../Middlewares/ST/hsp_engine/common/core; ../../../../../../Middlewares/ST/hsp_engine/common/utilities; ../../../../../../Middlewares/ST/hsp_engine/common/proclist; ../../../../../../Middlewares/ST/hsp_engine/interfaces; ../../../../../../Middlewares/ST/hsp_engine/common/modules/direct_lib; ../../../../../../Middlewares/ST/hsp_engine/common/modules/firmware; ../../../../../../Middlewares/ST/hsp_engine/common/modules/firmware/crom_1.1.7/cram_1.7; ../../../../../../Middlewares/ST/hsp_engine/common/modules; ../../../../../../Middlewares/ST/hsp_engine/common/modules/proclist_lib
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: fir_seq.hex
  ILINK.IlinkOutputFile: fir_seq.out
  ILINK.IlinkIcfFile: stm32u3c5xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32u3c5xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32u3xx_it.c stm32u3xx_hal_msp.c
  group Application/User/HSP_Engine/App
    ../HSP_Engine/App/: app_hsp_engine_seq.c hsp_engine.c app_hsp_bram_alloc.c app_hsp_engine_process.c
  group Application/User/HSP_Engine/Target
    ../HSP_Engine/Target/: hsp_if_conf.c
  group Doc
    ../: README.md
  group Drivers/BSP/STM32U3xx_Nucleo
    ../../../../../../Drivers/BSP/STM32U3xx_Nucleo/: stm32u3xx_nucleo.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32u3xx.c
  group Drivers/CMSIS/Math
    ../../../../../../Drivers/CMSIS/DSP/Source/StatisticsFunctions/: arm_rms_f32.c
  group Drivers/STM32U3xx_HAL_Driver
    ../../../../../../Drivers/STM32U3xx_HAL_Driver/Src/: stm32u3xx_hal_exti.c stm32u3xx_hal_icache.c stm32u3xx_hal_hsp.c stm32u3xx_hal.c stm32u3xx_hal_rcc.c stm32u3xx_hal_rcc_ex.c stm32u3xx_hal_cortex.c stm32u3xx_hal_flash.c stm32u3xx_hal_flash_ex.c stm32u3xx_hal_gpio.c stm32u3xx_hal_dma.c stm32u3xx_hal_dma_ex.c stm32u3xx_hal_pwr.c stm32u3xx_hal_pwr_ex.c stm32u3xx_hal_gtzc.c stm32u3xx_hal_tim.c stm32u3xx_hal_tim_ex.c
  group Middlewares/HSP_Engine/Core
    ../../../../../../Middlewares/ST/hsp_engine/common/proclist/: hsp_proclist.c
    ../../../../../../Middlewares/ST/hsp_engine/common/core/: hsp_core.c hsp_bram.c
  group Middlewares/HSP_Engine/interfaces
    ../../../../../../Middlewares/ST/hsp_engine/interfaces/: hsp_bram_if.c hsp_hw_if.c hsp_utilities.c
    ../../../../../../Middlewares/ST/hsp_engine/common/utilities/: hsp_memcpy.c
    ../../../../../../Middlewares/ST/hsp_engine/common/utilities/portable/IAR/: st_hsp_memcpy32.s
  group Middlewares/HSP_Engine/modules
    ../../../../../../Middlewares/ST/hsp_engine/common/modules/direct_lib/: hsp_direct_command.c
    ../../../../../../Middlewares/ST/hsp_engine/common/modules/proclist_lib/: hsp_proclist_complex.c hsp_proclist_conditional.c hsp_proclist_filter.c hsp_proclist_matrix.c hsp_proclist_scalar.c hsp_proclist_transform.c hsp_proclist_vector.c
    ../../../../../../Middlewares/ST/hsp_engine/common/modules/firmware/crom_1.1.7/cram_1.7/: hsp_fw_ram.c
  group Middlewares/HSP_Engine/modules/firmware
    ../../../../../../Middlewares/ST/hsp_engine/common/modules/firmware/crom_1.1.7/cram_1.7/: hsp_fw_ram.c
  group Middlewares/HSP_Engine/ProcList
    ../../../../../../Middlewares/ST/hsp_engine/common/proclist/: hsp_proclist.c
