# Keil uVision project fir_seq.uvprojx, settings and files
target fir_seq (6210000::V6.21::ARMCLANG)
  device: STM32U3C5ZITxQ STMicroelectronics
  pack: Keil.STM32U3xx_DFP.1.3.0-A01
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x20030000-0x2003FFFF) IROM(0x08000000-0x81FFFFF)  CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: fir_seq +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HSP_ARM_MATH_TYPES,USE_HAL_HSP_CUBE1_LEGACY,USE_HAL_DRIVER,STM32U3C5xx
  c include: ../HSP_Engine/App;../HSP_Engine/Target;../Core/Inc;../../../../../../Drivers/STM32U3xx_HAL_Driver/Inc;../../../../../../Drivers/CMSIS/DSP/Include;../../../../../../Drivers/STM32U3xx_HAL_Driver/Inc/Legacy;../../../../../../Middlewares/ST/hsp_engine/common/core;../../../../../../Middlewares/ST/hsp_engine/common/proclist;../../../../../../Middlewares/ST/hsp_engine/interfaces;../../../../../../Middlewares/ST/hsp_engine/common/utilities;../../../../../../Middlewares/ST/hsp_engine/common/modules/direct_lib;../../../../../../Middlewares/ST/hsp_engine/common/modules/proclist_lib;../../../../../../Middlewares/ST/hsp_engine/common/modules/firmware;../../../../../../Middlewares/ST/hsp_engine/common/modules/firmware/crom_1.1.7/cram_1.7;../../../../../../Drivers/CMSIS/Device/ST/STM32U3xx/Include;../../../../../../Middlewares/ST/hsp_engine/common/modules;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/BSP/STM32U3xx_Nucleo;../../../../../../Drivers/CMSIS/DSP/Include/dsp
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x20030000 size 0x10000
  scatter file: stm32u3c5xx_flash.sct
  link misc: --diag_suppress=L6314
  group Application/MDK-ARM
    ./: startup_stm32u3c5xx.s
  group Application/User/HSP_Engine/App
    ../HSP_Engine/App/: app_hsp_engine_seq.c hsp_engine.c app_hsp_bram_alloc.c app_hsp_engine_process.c
  group Application/User/HSP_Engine/Target
    ../HSP_Engine/Target/: hsp_if_conf.c
  group Application/User/Core
    ../Core/Src/: main.c stm32u3xx_it.c stm32u3xx_hal_msp.c
  group Doc
    ../: README.md
  group Drivers/BSP/STM32U3xx_Nucleo
    ../../../../../../Drivers/BSP/STM32U3xx_Nucleo/: stm32u3xx_nucleo.c
  group Drivers/STM32U3xx_HAL_Driver
    ../../../../../../Drivers/STM32U3xx_HAL_Driver/Src/: stm32u3xx_hal_exti.c stm32u3xx_hal_icache.c stm32u3xx_hal_hsp.c stm32u3xx_hal.c stm32u3xx_hal_rcc.c stm32u3xx_hal_rcc_ex.c stm32u3xx_hal_cortex.c stm32u3xx_hal_flash.c stm32u3xx_hal_flash_ex.c stm32u3xx_hal_gpio.c stm32u3xx_hal_dma.c stm32u3xx_hal_dma_ex.c stm32u3xx_hal_pwr.c stm32u3xx_hal_pwr_ex.c stm32u3xx_hal_gtzc.c stm32u3xx_hal_tim.c stm32u3xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32u3xx.c
  group Drivers/CMSIS/Math
    ../../../../../../Drivers/CMSIS/DSP/Source/StatisticsFunctions/: arm_rms_f32.c
  group Middlewares/HSP_Engine/Core
    ../../../../../../Middlewares/ST/hsp_engine/common/core/: hsp_core.c hsp_bram.c
  group Middlewares/HSP_Engine/ProcList
    ../../../../../../Middlewares/ST/hsp_engine/common/proclist/: hsp_proclist.c
  group Middlewares/HSP_Engine/interfaces
    ../../../../../../Middlewares/ST/hsp_engine/interfaces/: hsp_bram_if.c hsp_hw_if.c hsp_utilities.c
    ../../../../../../Middlewares/ST/hsp_engine/common/utilities/: hsp_memcpy.c
    ../../../../../../Middlewares/ST/hsp_engine/common/utilities/portable/Keil/: st_hsp_memcpy32.s
  group Middlewares/HSP_Engine/modules
    ../../../../../../Middlewares/ST/hsp_engine/common/modules/direct_lib/: hsp_direct_command.c
    ../../../../../../Middlewares/ST/hsp_engine/common/modules/proclist_lib/: hsp_proclist_complex.c hsp_proclist_conditional.c hsp_proclist_filter.c hsp_proclist_matrix.c hsp_proclist_scalar.c hsp_proclist_transform.c hsp_proclist_vector.c
    ../../../../../../Middlewares/ST/hsp_engine/common/modules/firmware/crom_1.1.7/cram_1.7/: hsp_fw_ram.c
software components: CMSIS:CORE 5.6.0
