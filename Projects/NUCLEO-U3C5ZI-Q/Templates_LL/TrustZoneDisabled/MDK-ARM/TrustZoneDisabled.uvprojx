# Keil uVision project TrustZoneDisabled.uvprojx, settings and files
target TrustZoneDisabled (6210000::V6.21::ARMCLANG)
  device: STM32U3C5ZITxQ STMicroelectronics
  pack: Keil.STM32U3xx_DFP.1.3.0-A01
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x20030000-0x2003FFFF) IROM(0x08000000-0x81FFFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: TrustZoneDisabled +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,HSE_VALUE=16000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,MSI_VALUE=96000000,EXTERNALSAI1_CLOCK_VALUE=48000,HSI_VALUE=16000000,LSI_VALUE=32000,VDD_VALUE=3300,STM32U3C5xx
  c include: ../Inc;../../../../../Drivers/STM32U3xx_HAL_Driver/Inc;../../../../../Drivers/CMSIS/Device/ST/STM32U3xx/Include;../../../../../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x20030000 size 0x10000
  scatter file: stm32u3c5xx_flash.sct
  link misc: --diag_suppress=L6314
  group Application/MDK-ARM
    ./: startup_stm32u3c5xx.s
  group Application/User
    ../Src/: main.c stm32u3xx_it.c
  group Drivers/STM32U3xx_HAL_Driver
    ../../../../../Drivers/STM32U3xx_HAL_Driver/Src/: stm32u3xx_ll_exti.c stm32u3xx_ll_utils.c stm32u3xx_ll_gpio.c stm32u3xx_ll_icache.c stm32u3xx_ll_pwr.c
  group Drivers/CMSIS
    ../Src/: system_stm32u3xx.c
  group Doc
    ../: README.md
software components: CMSIS:CORE 5.6.0
