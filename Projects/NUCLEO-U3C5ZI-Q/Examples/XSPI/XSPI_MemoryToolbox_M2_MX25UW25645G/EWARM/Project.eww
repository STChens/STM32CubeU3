<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\XSPI_MemoryToolbox_M2_MX25UW25645G.ewp</path>
  </project>
  <batchBuild />
</workspace>
