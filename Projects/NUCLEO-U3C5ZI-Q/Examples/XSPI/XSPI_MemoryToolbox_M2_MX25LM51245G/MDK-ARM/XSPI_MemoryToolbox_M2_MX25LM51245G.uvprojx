# Keil uVision project XSPI_MemoryToolbox_M2_MX25LM51245G.uvprojx, settings and files
target XSPI_MemoryToolbox_M2_MX25LM51245G (6210000::V6.21::ARMCLANG)
  device: STM32U3C5ZITxQ STMicroelectronics
  pack: Keil.STM32U3xx_DFP.1.2.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x20030000-0x2003FFFF) IROM(0x08000000-0x81FFFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: XSPI_MemoryToolbox_M2_MX25LM51245G +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: M2_MX25LM51245G,EXAMPLE_TRACE_ENABLE,USE_HAL_DRIVER,STM32U3C5xx
  c include: ../Inc;../../../../../../Drivers/STM32U3xx_HAL_Driver/Inc;../../../../../../Drivers/STM32U3xx_HAL_Driver/Inc/Legacy;../../../../../../Drivers/CMSIS/Device/ST/STM32U3xx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/BSP/STM32U3xx_Nucleo
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x20030000 size 0x10000
  scatter file: stm32u3c5xx_flash.sct
  link misc: --diag_suppress=L6314
  group Application/MDK-ARM
    ./: startup_stm32u3c5xx.s
  group Application/User
    ../Src/: memory_toolbox.c main.c stm32u3xx_it.c stm32u3xx_hal_msp.c
    ./: Serial.c Retarget.c
  group Doc
    ../: README.md
  group Drivers/BSP/STM32U3xx_Nucleo
    ../../../../../../Drivers/BSP/STM32U3xx_Nucleo/: stm32u3xx_nucleo.c
  group Drivers/STM32U3xx_HAL_Driver
    ../../../../../../Drivers/STM32U3xx_HAL_Driver/Src/: stm32u3xx_hal_cortex.c stm32u3xx_hal.c stm32u3xx_hal_rcc.c stm32u3xx_hal_rcc_ex.c stm32u3xx_hal_flash.c stm32u3xx_hal_flash_ex.c stm32u3xx_hal_gpio.c stm32u3xx_hal_dma.c stm32u3xx_hal_dma_ex.c stm32u3xx_hal_exti.c stm32u3xx_hal_pwr.c stm32u3xx_hal_pwr_ex.c stm32u3xx_hal_gtzc.c stm32u3xx_hal_icache.c stm32u3xx_hal_xspi.c stm32u3xx_ll_dlyb.c stm32u3xx_hal_tim.c stm32u3xx_hal_tim_ex.c stm32u3xx_hal_uart.c stm32u3xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32u3xx.c
software components: CMSIS:CORE 5.6.0
