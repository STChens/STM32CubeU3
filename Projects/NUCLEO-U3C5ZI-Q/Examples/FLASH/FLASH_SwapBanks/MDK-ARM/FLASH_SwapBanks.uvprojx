# Keil uVision project FLASH_SwapBanks.uvprojx, settings and files
target FLASH_SwapBanks_Bank1 (6210000::V6.21::ARMCLANG)
  device: STM32U3C5ZITxQ STMicroelectronics
  pack: Keil.STM32U3xx_DFP.1.3.0-A01
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x20030000,0x00010000) IROM(0x08000000,0x00200000) XRAM(0x20040000,0x00050000) XRAM2(0x20090000,0x00010000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: FLASH_SwapBanks_BANK1 +hex
  AfterMake: fromelf #L --bin --output=$L@L.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32U3C5xx,FLASH_BANK1
  c include: ../Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32U3xx/Include;../../../../../../Drivers/STM32U3xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32U3xx_Nucleo;../../../../../../Drivers/BSP/Components/Common
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT6: RAM 0x20040000 size 0x50000
  memory RVCT7: RAM 0x20090000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x20030000 size 0x10000
  scatter file: stm32u3c5xx_flash.sct
  link misc: --diag_suppress=L6314
  group Doc
    ../: README.md
  group Drivers/BSP
    ../../../../../../Drivers/BSP/STM32U3xx_Nucleo/: stm32u3xx_nucleo.c
  group Drivers/CMSIS
    ../Src/: system_stm32u3xx.c
  group Drivers/STM32U3xx_HAL_Driver
    ../../../../../../Drivers/STM32U3xx_HAL_Driver/Src/: stm32u3xx_hal.c stm32u3xx_hal_cortex.c stm32u3xx_hal_dma.c stm32u3xx_hal_dma_ex.c stm32u3xx_hal_exti.c stm32u3xx_hal_flash.c stm32u3xx_hal_flash_ex.c stm32u3xx_hal_gpio.c stm32u3xx_hal_i2c.c stm32u3xx_hal_icache.c stm32u3xx_hal_pwr.c stm32u3xx_hal_pwr_ex.c stm32u3xx_hal_rcc.c stm32u3xx_hal_rcc_ex.c stm32u3xx_hal_usart.c stm32u3xx_hal_usart_ex.c
  group Application/MDK-ARM
    ./: startup_stm32u3c5xx.s
  group Application/User
    ../Src/: main.c stm32u3xx_it.c stm32u3xx_hal_msp.c
target FLASH_SwapBanks_Bank2 (6210000::V6.21::ARMCLANG)
  device: STM32U3C5ZITxQ STMicroelectronics
  pack: Keil.STM32U3xx_DFP.1.3.0-A01
  cpu: as above
  output: FLASH_SwapBanks_BANK2 +hex
  AfterMake: fromelf #L --bin --output=$L@L.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32U3C5xx,FLASH_BANK2
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT6: RAM 0x20040000 size 0x50000
  memory RVCT7: RAM 0x20090000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x20030000 size 0x10000
  scatter file: stm32u3c5xx_flash.sct
  link misc: --diag_suppress=L6314
software components: CMSIS:CORE 5.6.0
