<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\OEMiROT_Boot\EWARM\Project.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\OEMiROT_Appli\EWARM\Project_s.ewp</path>
    </project>    
</workspace>
