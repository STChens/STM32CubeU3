# Keil uVision project OpenBootloader.uvprojx, settings and files
target NUCLEO-U385RG (6180000::V6.18::ARMCLANG)
  device: STM32U385RGTxQ STMicroelectronics
  pack: Keil.STM32U3xx_DFP.1.0.0
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0x08000000-0x80FFFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ
  output: Project +hex
  AfterMake: fromelf #L --bin --output=$L@L.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32U385xx,UX_INCLUDE_USER_DEFINE_FILE
  c include: ../OpenBootloader/App;../OpenBootloader/Target;../../../../../Middlewares/ST/usbx/common/core/inc;../../../../../Middlewares/ST/usbx/ports/generic/inc;../../../../../Middlewares/ST/usbx/common/usbx_host_controllers/inc;../../../../../Middlewares/ST/usbx/common/usbx_device_classes/inc;../../../../../Drivers/STM32U3xx_HAL_Driver/Inc;../../../../../Middlewares/ST/OpenBootloader/Core;../../../../../Middlewares/ST/OpenBootloader/Modules/I2C;../../../../../Middlewares/ST/OpenBootloader/Modules/Mem;../../../../../Middlewares/ST/OpenBootloader/Modules/SPI;../../../../../Middlewares/ST/OpenBootloader/Modules/USART;../../../../../Middlewares/ST/OpenBootloader/Modules/USB;../../../../../Drivers/CMSIS/Device/ST/STM32U3xx/Include;../Core/Inc;../../../../../Drivers/CMSIS/Include;../USBX/App;../USBX/Target;../../../../../Middlewares/ST/OpenBootloader/Modules/I3C;../../../../../Middlewares/ST/usbx/common/usbx_stm32_device_controllers
  memory RVCT4: ROM 0x8000000 size 0xc5ff
  memory RVCT9: RAM 0x20000000 size 0x30000
  group Application/Core
    ../Core/Src/: main.c stm32u3xx_hal_msp.c stm32u3xx_it.c
  group Application/MDK-ARM
    ./: startup_stm32u385xx.s
  group Application/OpenBootloader/App
    ../OpenBootloader/App/: app_openbootloader.c
  group Application/OpenBootloader/Target
    ../OpenBootloader/Target/: common_interface.c engibytes_interface.c flash_interface.c i2c_interface.c i3c_interface.c iwdg_interface.c optionbytes_interface.c otp_interface.c ram_interface.c spi_interface.c systemmemory_interface.c usart_interface.c usb_interface.c
  group Application/USBX/App
    ../USBX/App/: app_usbx_device.c ux_device_descriptors.c ux_device_dfu_media.c
  group Doc
    ../: README.md
  group Drivers/CMSIS
    ../Core/Src/: system_stm32u3xx.c
  group Drivers/STM32U3xx_HAL_Driver
    ../../../../../Drivers/STM32U3xx_HAL_Driver/Src/: stm32u3xx_hal.c stm32u3xx_hal_adc.c stm32u3xx_hal_adc_ex.c stm32u3xx_hal_cortex.c stm32u3xx_hal_crc.c stm32u3xx_hal_crc_ex.c stm32u3xx_hal_dma.c stm32u3xx_hal_dma_ex.c stm32u3xx_hal_flash.c stm32u3xx_hal_flash_ex.c stm32u3xx_hal_gpio.c stm32u3xx_hal_i2c.c stm32u3xx_hal_i2c_ex.c stm32u3xx_hal_i3c.c stm32u3xx_hal_iwdg.c stm32u3xx_hal_pcd.c stm32u3xx_hal_pcd_ex.c stm32u3xx_hal_pwr.c stm32u3xx_hal_pwr_ex.c stm32u3xx_hal_rcc.c stm32u3xx_hal_rcc_ex.c stm32u3xx_hal_spi.c stm32u3xx_hal_spi_ex.c stm32u3xx_hal_tim.c stm32u3xx_hal_tim_ex.c stm32u3xx_hal_usart.c stm32u3xx_hal_usart_ex.c stm32u3xx_ll_crc.c stm32u3xx_ll_dma.c stm32u3xx_ll_gpio.c stm32u3xx_ll_i2c.c stm32u3xx_ll_i3c.c stm32u3xx_ll_rcc.c stm32u3xx_ll_spi.c stm32u3xx_ll_usart.c stm32u3xx_ll_usb.c
  group Middlewares/OpenBootloader/Core
    ../../../../../Middlewares/ST/OpenBootloader/Core/: openbl_core.c
  group Middlewares/OpenBootloader/Modules/I2C
    ../../../../../Middlewares/ST/OpenBootloader/Modules/I2C/: openbl_i2c_cmd.c
  group Middlewares/OpenBootloader/Modules/I3C
    ../../../../../Middlewares/ST/OpenBootloader/Modules/I3C/: openbl_i3c_cmd.c
  group Middlewares/OpenBootloader/Modules/MEM
    ../../../../../Middlewares/ST/OpenBootloader/Modules/Mem/: openbl_mem.c
  group Middlewares/OpenBootloader/Modules/SPI
    ../../../../../Middlewares/ST/OpenBootloader/Modules/SPI/: openbl_spi_cmd.c
  group Middlewares/OpenBootloader/Modules/USART
    ../../../../../Middlewares/ST/OpenBootloader/Modules/USART/: openbl_usart_cmd.c
  group Middlewares/OpenBootloader/Modules/USB
    ../../../../../Middlewares/ST/OpenBootloader/Modules/USB/: openbl_usb_cmd.c
  group Middlewares/USBX/Core System
    ../../../../../Middlewares/ST/usbx/common/core/src/: ux_system_error_handler.c ux_system_initialize.c ux_system_tasks_run.c ux_system_uninitialize.c ux_utility_debug_callback_register.c ux_utility_debug_log.c ux_utility_delay_ms.c ux_utility_descriptor_pack.c ux_utility_descriptor_parse.c ux_utility_error_callback_register.c ux_utility_event_flags_create.c ux_utility_event_flags_delete.c ux_utility_event_flags_get.c ux_utility_event_flags_set.c ux_utility_long_get.c ux_utility_long_get_big_endian.c ux_utility_long_put.c ux_utility_long_put_big_endian.c ux_utility_memory_allocate.c ux_utility_memory_allocate_add_safe.c ux_utility_memory_allocate_mulc_safe.c ux_utility_memory_allocate_mulv_safe.c ux_utility_memory_byte_pool_create.c ux_utility_memory_byte_pool_search.c ux_utility_memory_compare.c ux_utility_memory_copy.c ux_utility_memory_free.c ux_utility_memory_free_block_best_get.c ux_utility_memory_set.c ux_utility_pci_class_scan.c ux_utility_pci_read.c ux_utility_pci_write.c ux_utility_physical_address.c ux_utility_set_interrupt_handler.c ux_utility_short_get.c ux_utility_short_get_big_endian.c ux_utility_short_put.c ux_utility_short_put_big_endian.c ux_utility_string_length_check.c ux_utility_string_length_get.c ux_utility_string_to_unicode.c ux_utility_unicode_to_string.c ux_utility_virtual_address.c
  group Middlewares/USBX/UX Device Class DFU
    ../../../../../Middlewares/ST/usbx/common/usbx_device_classes/src/: ux_device_class_dfu_activate.c ux_device_class_dfu_control_request.c ux_device_class_dfu_deactivate.c ux_device_class_dfu_entry.c ux_device_class_dfu_initialize.c ux_device_class_dfu_state_get.c ux_device_class_dfu_state_sync.c ux_device_class_dfu_tasks_run.c
  group Middlewares/USBX/UX Device Controllers
    ../../../../../Middlewares/ST/usbx/common/usbx_stm32_device_controllers/: ux_dcd_stm32_callback.c ux_dcd_stm32_endpoint_create.c ux_dcd_stm32_endpoint_destroy.c ux_dcd_stm32_endpoint_reset.c ux_dcd_stm32_endpoint_stall.c ux_dcd_stm32_endpoint_status.c ux_dcd_stm32_frame_number_get.c ux_dcd_stm32_function.c ux_dcd_stm32_initialize.c ux_dcd_stm32_initialize_complete.c ux_dcd_stm32_interrupt_handler.c ux_dcd_stm32_transfer_abort.c ux_dcd_stm32_transfer_request.c ux_dcd_stm32_transfer_run.c ux_dcd_stm32_uninitialize.c
  group Middlewares/USBX/UX Device CoreStack
    ../../../../../Middlewares/ST/usbx/common/core/src/: ux_device_stack_alternate_setting_get.c ux_device_stack_alternate_setting_set.c ux_device_stack_class_register.c ux_device_stack_class_unregister.c ux_device_stack_clear_feature.c ux_device_stack_configuration_get.c ux_device_stack_configuration_set.c ux_device_stack_control_request_process.c ux_device_stack_descriptor_send.c ux_device_stack_disconnect.c ux_device_stack_endpoint_stall.c ux_device_stack_get_status.c ux_device_stack_host_wakeup.c ux_device_stack_initialize.c ux_device_stack_interface_delete.c ux_device_stack_interface_get.c ux_device_stack_interface_set.c ux_device_stack_interface_start.c ux_device_stack_microsoft_extension_register.c ux_device_stack_set_feature.c ux_device_stack_tasks_run.c ux_device_stack_transfer_abort.c ux_device_stack_transfer_all_request_abort.c ux_device_stack_transfer_request.c ux_device_stack_transfer_run.c ux_device_stack_uninitialize.c
software components: CMSIS:CORE 5.6.0
